# Keil uVision project IIC_CST816T_LCD_driver.uvprojx, settings and files
target IIC_CST816T_LCD_driver (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F411CEUx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0x8000000-0x807FFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: IIC_CST816T_LCD_driver +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F411xE
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../BSP/CST816T/Driver/Inc;../BSP/ST7789/Driver/Inc;../Components/RTT;../Components/easylogger/inc;../Middlewares/LVGL/lvgl;../Middlewares/LVGL;../Middlewares/LVGL/LVGL_ui;../Middlewares/LVGL/lvgl/src;../Middlewares/LVGL/lvgl/examples/porting;..\Middlewares\LVGL\LVGL_ui\analogclock
  asm include: ../Core/Inc
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Application/MDK-ARM
    ./: startup_stm32f411xe.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c freertos.c dma.c i2c.c spi.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c stm32f4xx_hal_timebase_tim.c
  group BSP/CST816T
    ../BSP/CST816T/Driver/Src/: bsp_cst816t_driver.c
  group BSP/ST7789
    ../BSP/ST7789/Driver/Src/: bsp_st7789_driver.c fonts.c st7789.c
  group Component/easylogger
    ../Components/easylogger/src/: elog.c elog_utils.c
    ../Components/easylogger/port/: elog_port.c
  group Component/RTT
    ../Components/RTT/: SEGGER_RTT.c SEGGER_RTT_printf.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group Midderware/LVGL/lvgl
    ../Middlewares/LVGL/lvgl/examples/porting/: lv_port_disp_template.c lv_port_fs_template.c lv_port_indev_template.c
    ../Middlewares/LVGL/lvgl/src/core/: lv_disp.c lv_event.c lv_group.c lv_indev.c lv_indev_scroll.c lv_obj.c lv_obj_class.c lv_obj_draw.c lv_obj_pos.c lv_obj_scroll.c lv_obj_style.c lv_obj_style_gen.c lv_obj_tree.c lv_refr.c lv_theme.c
    ../Middlewares/LVGL/lvgl/src/draw/arm2d/: lv_gpu_arm2d.c
    ../Middlewares/LVGL/lvgl/src/draw/nxp/pxp/: lv_draw_pxp.c lv_draw_pxp_blend.c lv_gpu_nxp_pxp.c lv_gpu_nxp_pxp_osa.c
    ../Middlewares/LVGL/lvgl/src/draw/nxp/vglite/: lv_draw_vglite.c lv_draw_vglite_arc.c lv_draw_vglite_blend.c lv_draw_vglite_line.c lv_draw_vglite_rect.c lv_vglite_buf.c lv_vglite_utils.c
    ../Middlewares/LVGL/lvgl/src/draw/renesas/: lv_gpu_d2_draw_label.c lv_gpu_d2_ra6m3.c
    ../Middlewares/LVGL/lvgl/src/draw/sdl/: lv_draw_sdl.c lv_draw_sdl_arc.c lv_draw_sdl_bg.c lv_draw_sdl_composite.c lv_draw_sdl_img.c lv_draw_sdl_label.c lv_draw_sdl_layer.c lv_draw_sdl_line.c lv_draw_sdl_mask.c lv_draw_sdl_polygon.c lv_draw_sdl_rect.c lv_draw_sdl_stack_blur.c lv_draw_sdl_texture_cache.c lv_draw_sdl_utils.c
    ../Middlewares/LVGL/lvgl/src/draw/stm32_dma2d/: lv_gpu_stm32_dma2d.c
    ../Middlewares/LVGL/lvgl/src/draw/sw/: lv_draw_sw.c lv_draw_sw_arc.c lv_draw_sw_blend.c lv_draw_sw_dither.c lv_draw_sw_gradient.c lv_draw_sw_img.c lv_draw_sw_layer.c lv_draw_sw_letter.c lv_draw_sw_line.c lv_draw_sw_polygon.c lv_draw_sw_rect.c lv_draw_sw_transform.c
    ../Middlewares/LVGL/lvgl/src/draw/swm341_dma2d/: lv_gpu_swm341_dma2d.c
    ../Middlewares/LVGL/lvgl/src/draw/: lv_draw.c lv_draw_arc.c lv_draw_img.c lv_draw_label.c lv_draw_layer.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_transform.c lv_draw_triangle.c lv_img_buf.c lv_img_cache.c lv_img_decoder.c
    ../Middlewares/LVGL/lvgl/src/extra/layouts/flex/: lv_flex.c
    ../Middlewares/LVGL/lvgl/src/extra/layouts/grid/: lv_grid.c
    ../Middlewares/LVGL/lvgl/src/extra/libs/bmp/: lv_bmp.c
    ../Middlewares/LVGL/lvgl/src/extra/libs/ffmpeg/: lv_ffmpeg.c
    ../Middlewares/LVGL/lvgl/src/extra/libs/freetype/: lv_freetype.c
    ../Middlewares/LVGL/lvgl/src/extra/libs/fsdrv/: lv_fs_fatfs.c lv_fs_posix.c lv_fs_stdio.c lv_fs_win32.c
    ../Middlewares/LVGL/lvgl/src/extra/libs/gif/: gifdec.c lv_gif.c
    ../Middlewares/LVGL/lvgl/src/extra/libs/png/: lodepng.c lv_png.c
    ../Middlewares/LVGL/lvgl/src/extra/libs/qrcode/: lv_qrcode.c qrcodegen.c
    ../Middlewares/LVGL/lvgl/src/extra/libs/rlottie/: lv_rlottie.c
    ../Middlewares/LVGL/lvgl/src/extra/libs/sjpg/: lv_sjpg.c tjpgd.c
    ../Middlewares/LVGL/lvgl/src/extra/others/fragment/: lv_fragment.c lv_fragment_manager.c
    ../Middlewares/LVGL/lvgl/src/extra/others/gridnav/: lv_gridnav.c
    ../Middlewares/LVGL/lvgl/src/extra/others/ime/: lv_ime_pinyin.c
    ../Middlewares/LVGL/lvgl/src/extra/others/imgfont/: lv_imgfont.c
    ../Middlewares/LVGL/lvgl/src/extra/others/monkey/: lv_monkey.c
    ../Middlewares/LVGL/lvgl/src/extra/others/msg/: lv_msg.c
    ../Middlewares/LVGL/lvgl/src/extra/others/snapshot/: lv_snapshot.c
    ../Middlewares/LVGL/lvgl/src/extra/themes/basic/: lv_theme_basic.c
    ../Middlewares/LVGL/lvgl/src/extra/themes/default/: lv_theme_default.c
    ../Middlewares/LVGL/lvgl/src/extra/themes/mono/: lv_theme_mono.c
    ../Middlewares/LVGL/lvgl/src/extra/widgets/animimg/: lv_animimg.c
    ../Middlewares/LVGL/lvgl/src/extra/widgets/calendar/: lv_calendar.c lv_calendar_header_arrow.c lv_calendar_header_dropdown.c
    ../Middlewares/LVGL/lvgl/src/extra/widgets/chart/: lv_chart.c
    ../Middlewares/LVGL/lvgl/src/extra/widgets/colorwheel/: lv_colorwheel.c
    ../Middlewares/LVGL/lvgl/src/extra/widgets/imgbtn/: lv_imgbtn.c
    ../Middlewares/LVGL/lvgl/src/extra/widgets/keyboard/: lv_keyboard.c
    ../Middlewares/LVGL/lvgl/src/extra/widgets/led/: lv_led.c
    ../Middlewares/LVGL/lvgl/src/extra/widgets/list/: lv_list.c
    ../Middlewares/LVGL/lvgl/src/extra/widgets/menu/: lv_menu.c
    ../Middlewares/LVGL/lvgl/src/extra/widgets/meter/: lv_meter.c
    ../Middlewares/LVGL/lvgl/src/extra/widgets/msgbox/: lv_msgbox.c
    ../Middlewares/LVGL/lvgl/src/extra/widgets/span/: lv_span.c
    ../Middlewares/LVGL/lvgl/src/extra/widgets/spinbox/: lv_spinbox.c
    ../Middlewares/LVGL/lvgl/src/extra/widgets/spinner/: lv_spinner.c
    ../Middlewares/LVGL/lvgl/src/extra/widgets/tabview/: lv_tabview.c
    ../Middlewares/LVGL/lvgl/src/extra/widgets/tileview/: lv_tileview.c
    ../Middlewares/LVGL/lvgl/src/extra/widgets/win/: lv_win.c
    ../Middlewares/LVGL/lvgl/src/extra/: lv_extra.c
    ../Middlewares/LVGL/lvgl/src/font/: lv_font.c lv_font_dejavu_16_persian_hebrew.c lv_font_fmt_txt.c lv_font_loader.c lv_font_montserrat_8.c lv_font_montserrat_10.c lv_font_montserrat_12.c lv_font_montserrat_12_subpx.c lv_font_montserrat_14.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28.c lv_font_montserrat_28_compressed.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_simsun_16_cjk.c lv_font_unscii_8.c lv_font_unscii_16.c
    ../Middlewares/LVGL/lvgl/src/hal/: lv_hal_disp.c lv_hal_indev.c lv_hal_tick.c
    ../Middlewares/LVGL/lvgl/src/misc/: lv_anim.c lv_anim_timeline.c lv_area.c lv_async.c lv_bidi.c lv_color.c lv_fs.c lv_gc.c lv_ll.c lv_log.c lv_lru.c lv_math.c lv_mem.c lv_printf.c lv_style.c lv_style_gen.c lv_templ.c lv_timer.c lv_tlsf.c lv_txt.c lv_txt_ap.c lv_utils.c
    ../Middlewares/LVGL/lvgl/src/widgets/: lv_arc.c lv_bar.c lv_btn.c lv_btnmatrix.c lv_canvas.c lv_checkbox.c lv_dropdown.c lv_img.c lv_label.c lv_line.c lv_objx_templ.c lv_roller.c lv_slider.c lv_switch.c lv_table.c lv_textarea.c
  group Midderware/LVGL/ui
    ../Middlewares/LVGL/LVGL_ui/: events_init.c gui_guider.c setup_scr_screen.c widgets_init.c setup_scr_screen_1.c setup_scr_screen_2.c
    ../Middlewares/LVGL/LVGL_ui/images/: _biaopan_alpha_240x240.c _biaopan1_alpha_240x240.c _fen_alpha_70x5.c _miao_alpha_70x5.c _time_alpha_40x5.c
    ../Middlewares/LVGL/LVGL_ui/guider_fonts/: lv_font_alimama_12.c lv_font_alimama_16.c lv_font_alimama_24.c
    ../Middlewares/LVGL/LVGL_ui/analogclock/: lv_analogclock.c
software components: CMSIS:CORE 4.3.0
